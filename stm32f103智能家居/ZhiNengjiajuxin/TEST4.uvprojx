# Keil uVision project TEST4.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\Libraries\FWlib\inc;.\User;.\Libraries\CMSIS;.\User\dht11;.\User\Led;.\User\SysTick;.\User\flash;.\User\font;.\User\lcd;.\User\FENG;.\User\EXTI;.\User\KEY;.\User\ADC;.\User\breathinglight;.\User\i2c;..\ZhiNengjiajuxin;.\User\UART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ./User/dht11/: bsp_dht11.c bsp_dht11.h
    ./User/Led/: bsp_led.c bsp_led.h
    ./User/SysTick/: bsp_SysTick.c bsp_SysTick.h
    ./User/flash/: bsp_spi_flash.c bsp_spi_flash.h
    ./User/font/: fonts.c fonts.h
    ./User/lcd/: bsp_ili9341_lcd.c bsp_ili9341_lcd.h
    ./User/FENG/: feng.c feng.h
    ./User/EXTI/: exti.c exti.h
    ./User/KEY/: key.c key.h
    ./User/ADC/: adc.c adc.h
    ./User/breathinglight/: bsp_breathing.c bsp_breathing.h
    ./User/i2c/: bsp_i2c_ee.c bsp_i2c_ee.h bsp_i2c_gpio.c bsp_i2c_gpio.h
    ./User/UART/: uart.c uart.h
  group FWLIB
    ./Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ./Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
